# Keil uVision project Herbicidal.uvprojx, settings and files
target HERBICIDAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Herbicidal +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\User;..\..\User\systick;..\..\User\GPIO;..\..\User\led;..\..\User\Beep;..\..\User\key;..\..\User\basic_tim;..\..\User\UART4;..\..\User\USART1;..\..\User\USART2;..\..\User\USART3;..\..\User\USART6;..\..\User\ADC;..\..\User\Data_type;..\..\User\Control;..\..\User\relay;..\..\User\alarm;..\..\User\exti;..\..\User\Task;..\..\User\CRC;..\..\..\..\RS485;..\..\User\LCFunc;..\..\User\Manual;..\..\User\FullAuto;..\..\User\HalfAuto;..\..\User\RS485
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USER
    ../../User/: main.c stm32f4xx_it.c
    ../../User/systick/: bsp_SysTick.c
    ../../User/led/: bsp_led.c
    ../../User/key/: bsp_key.c
    ../../User/basic_tim/: bsp_basic_tim.c
    ../../User/Beep/: beep.c
    ../../User/USART1/: usart1.c
    ../../User/USART2/: usart2.c
    ../../User/USART3/: usart3.c
    ../../User/USART6/: usart6.c
    ../../User/UART4/: uart4.c
    ../../User/ADC/: ADC.c
    ../../User/Data_type/: Data_type.c
    ../../User/Control/: Control.c
    ../../User/relay/: relay.c
    ../../User/alarm/: alarm.c
    ../../User/exti/: exti.c
    ../../User/CRC/: CRC.c
    ../../User/RS485/: RS485.c
    ../../User/LCFunc/: LCFunc.c
    ../../User/Manual/: Manual.c
    ../../User/FullAuto/: FullAuto.c
    ../../User/HalfAuto/: HalfAuto.c
  group DOC
    ../../Doc/: 必读说明.txt
